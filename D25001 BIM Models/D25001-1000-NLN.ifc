Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-01-05T12:44:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Jan 05 12:44:43 2025 * Host: Yogoon * Database: C:\Users\gokul\AppData\Local\Temp\12a2bfed-2cb8-45bf-b3e1-161405e825a8\aed5b0d1-438f-4ed4-805a-93deb2aa036e\ifc * Database version: 5507 * Database creation date: Sun Jan 05 12:44:42 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Jan 05 12:44:43 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Jan 05 12:44:43 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: D25001-1000-NLN, D25001-NLN:D25001-1000-NLN:351273
In: Level 1
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Height: 27 mm; L1: 900 mm; Length: 1000 mm; Width: 1000 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_30_53_06 Bathroom mirrors; CAWS: N13/438 Mirrors_N13/63 Glass mirrors_N10/270 Mirrors; Constituents: n/a; Description: DolphinRoundMirrorWithLED; DurationUnit: year; ExpectedLife: n/a; Features: LED; IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: www.dolphinsolutions.co.uk; Material: Glass; ModelNumber: D25001-1000-NLN; ModelReference: DolphinSolutionsLimited_RoundMirrorWithLED; Name: Dolphin_RoundMirrorWithLED_D25001-1000-NLN; NBSCode: 45-35-55/310 Mirrors; NBSDescription: Bathroom mirrors; NominalHeight: 27; NominalLength: 1000; NominalWidth: 1000; Primary Material: Glass; ReplacementCost: n/a; Shape: Round; Size: 27x1000x1000; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: D25001-1000-NLN; Uniclass2015Code: Pr_40_30_53_06 Bathroom mirrors; Uniclass2015Title: Bathroom mirrors; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Generic Models; Family Name: D25001-NLN
Type - Pset_FurnitureTypeCommon - Description: DolphinRoundMirrorWithLED; NominalHeight: 8229.6 mm; NominalLength: 304800 mm
Pset_ManufacturerOccurrence - BarCode: n/a
Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_RoundMirrorWithLED; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: Dolphin_RoundMirrorWithLED_D25001-1000-NLN; Category: Generic Models
Pset_QuantityTakeOff - Reference: D25001-NLN:D25001-1000-NLN
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 1.46036 m2; Volume: 0.0177735 m3
Other - Family: D25001-NLN: D25001-1000-NLN; Family and Type: D25001-NLN: D25001-1000-NLN; Type: D25001-NLN: D25001-1000-NLN; Type Id: D25001-NLN: D25001-1000-NLN
Phasing - Phase Created: New Construction
